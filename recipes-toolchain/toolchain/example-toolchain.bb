require recipes-core/meta/meta-toolchain.bb

TOOLCHAIN_TARGET_TASK += " libxml2 boost"
